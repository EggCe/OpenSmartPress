/*
 * sprache.h - Sprachwahl der Weboberfläche (/sprache.js, beide Seiten)
 *
 * Die Seiten sind auf Deutsch geschrieben. Dieses Skript übersetzt sie im Browser ins Englische:
 *   - statischer Text, title-, placeholder- und aria-label-Attribute: beim Start und bei jedem Umschalten
 *     (der deutsche Originaltext wird je Knoten gemerkt, Zurückschalten stellt ihn wieder her),
 *   - Texte aus dem Seitenskript: T("deutscher Text {0}", wert) - Platzhalter {0}..{9},
 *   - Texte der Firmware (Zustand, Stoppgrund, Grund für "nicht bereit"): TF(text),
 *     im Deutschen mit echten Umlauten (die Firmware sendet ASCII),
 *   - Zahlen- und Datumsformat: LOC() liefert "de-DE" bzw. "en-US".
 * Die Wahl (Knöpfe DE/EN, Klasse .sprachwahl) steht in localStorage "wz_sprache"; ohne Wahl entscheidet
 * die Browsersprache. Protokoll und Meldungen der Firmware bleiben deutsch.
 *
 * Neue Texte: deutschen Text in der Seite schreiben und hier in WOERTER eintragen (Schlüssel = Text mit
 * zusammengefassten Leerzeichen). tools/sprache_pruefen.py findet fehlende Einträge; WOERTER muss
 * gültiges JSON bleiben (doppelte Anführungszeichen, kein Komma am Ende).
 */
#pragma once

static const char WEB_SPRACHE_JS[] = R"SPRACHE("use strict";
const WOERTER=/*WOERTER*/{
"Wägezelle":"Load cell",
"Pressen":"Pressing",
"Keine Verbindung zum Pico – Befehle sind gesperrt, die Seite verbindet sich von selbst neu.":"No connection to the Pico – commands are locked, the page reconnects automatically.",
"Wägezelle · ADS1256":"Load cell · ADS1256",
"Bedienen: nur was für die Produktion nötig ist · Einrichten: alle Einstellungen, Diagnose, Protokoll":"Operate: only what production needs · Setup: all settings, diagnostics, log",
"Bedienen: nur was für die Produktion nötig ist · Einrichten: alle Einstellungen, Simulation, Protokoll":"Operate: only what production needs · Setup: all settings, simulation, log",
"Bedienen":"Operate",
"Einrichten":"Setup",
"Sprache":"Language",
"Farbschema":"Colour scheme",
"Grün / Schwarz":"Green / black",
"Rot / Schwarz":"Red / black",
"Blau / Hell":"Blue / light",
"verbinde …":"connecting …",
"Hilfe":"Help",
"Hilfe ↗":"Help ↗",
"Gewicht":"Weight",
"Steuerung":"Controls",
"Datenrate":"Data rate",
"Anzeige":"Display",
"Gramm":"Grams",
"Fenster [s]":"Window [s]",
"Glättung":"Smoothing",
"aus":"off",
"Rohsignal":"Raw signal",
"Statistik [s]":"Statistics [s]",
"Min/Max-Band":"Min/max band",
"Y-Skala":"Y scale",
"Auto mit Null":"Auto with zero",
"Fest":"Fixed",
"von":"from",
"bis":"to",
"Mittelt etwa 2 s und setzt den Wert als Nullpunkt – nur bei entlasteter, ruhiger Zelle":"Averages for about 2 s and sets the value as zero point – only with an unloaded, steady cell",
"Tara":"Tare",
"Faktor mit einem bekannten Gewicht bestimmen":"Determine the factor with a known weight",
"Waage kalibrieren …":"Calibrate scale …",
"Tara, Faktor, Glättung, Datenrate und Ausgabemodus dauerhaft speichern (Befehl s)":"Save tare, factor, smoothing, data rate and output mode permanently (command s)",
"Speichern":"Save",
"Misst etwa 5 s ungeglättet und schreibt eine Rauschanalyse ins Protokoll – Zelle nicht berühren":"Measures about 5 s unsmoothed and writes a noise analysis to the log – do not touch the cell",
"Rauschtest":"Noise test",
"Misst nacheinander bei mehreren Datenraten (etwa 25 s) und vergleicht das Rauschen":"Measures at several data rates in turn (about 25 s) and compares the noise",
"Rauschvergleich":"Noise comparison",
"Gerätestatus ins Protokoll schreiben":"Write device status to the log",
"Bricht Tara, Kalibrierung oder Rauschtest ab (wie STOPP)":"Cancels tare, calibration or noise test (like STOP)",
"Auftrag abbrechen":"Cancel job",
"Diagrammdaten herunterladen (Zeit, Mittel, Min, Max, geglättet)":"Download chart data (time, mean, min, max, smoothed)",
"CSV speichern":"Save CSV",
"Verlauf · Zeit / Gewicht":"History · time / weight",
"Mausrad: zoomen · Ziehen: verschieben · Doppelklick: Auto":"Mouse wheel: zoom · drag: pan · double-click: auto",
"Antrieb · HB808C":"Drive · HB808C",
"Letzte Hub-Kalibrierung":"Last stroke calibration",
"Fährt langsam auf das Werkzeug, merkt sich den Werkzeug-Endpunkt (Weg 0) und fährt zurück – ohne Werkstück":"Moves slowly onto the tool, stores the tool end point (path 0) and returns – without workpiece",
"Fährt langsam auf das Werkzeug, merkt sich den Werkzeug-Endpunkt (Weg 0) und fährt zurück":"Moves slowly onto the tool, stores the tool end point (path 0) and returns",
"Hub kalibrieren":"Calibrate stroke",
"Auf 5 mm":"Up 5 mm",
"Auf 1 mm":"Up 1 mm",
"Ab 1 mm":"Down 1 mm",
"Ab 0,1 mm":"Down 0.1 mm",
"Taste Esc":"Esc key",
"STOPP":"STOP",
"warte auf Daten …":"waiting for data …",
"Protokoll":"Log",
"Befehl, z. B. r 2000 · nv 3 500 1000 2000 · k 5000":"Command, e.g. r 2000 · nv 3 500 1000 2000 · k 5000",
"Befehl, z. B. mp · sit · pr":"Command, e.g. mp · sit · pr",
"Senden":"Send",
"Waage kalibrieren":"Calibrate scale",
"Bestimmt den Faktor Counts → Gramm mit einem bekannten Gewicht. Vorher 15–30 min warmlaufen lassen, Datenrate 2000 SPS.":"Determines the factor counts → grams with a known weight. Let it warm up for 15–30 min first, data rate 2000 SPS.",
"Waage entlasten und tarieren":"Unload the scale and tare",
"Alles abnehmen und warten, bis die Anzeige ruhig ist.":"Remove everything and wait until the reading is steady.",
"Bekanntes Gewicht auflegen":"Place a known weight",
"Mittig, möglichst 5 kg oder mehr (kleine Gewichte vergrößern jeden Fehler). Etwa 10 s warten.":"Centred, preferably 5 kg or more (small weights magnify every error). Wait about 10 s.",
"Gewicht [g]":"Weight [g]",
"Kalibrieren":"Calibrate",
"Ergebnis prüfen und speichern":"Check the result and save",
"Schließen":"Close",
"Antrieb fährt":"Drive moving",
"… {0} weitere Zeilen im Protokoll":"… {0} more lines in the log",
"Befehl „{0}“ abgelehnt (HTTP {1})":"Command “{0}” rejected (HTTP {1})",
"Befehl „{0}“ nicht gesendet – keine Verbindung":"Command “{0}” not sent – no connection",
"# Browser: Befehl '{0}' konnte nicht gesendet werden":"# Browser: command '{0}' could not be sent",
"# Browser: Pico wurde neu gestartet":"# Browser: Pico was restarted",
"Tara läuft …":"Taring …",
"Kalibrierung läuft … Gewicht nicht berühren":"Calibrating … do not touch the weight",
"Neuer Faktor <b>{0}</b> Counts/g · Anzeige jetzt <b>{1} g</b>. Details (Empfindlichkeit, Unsicherheit) im Protokoll.":"New factor <b>{0}</b> counts/g · reading now <b>{1} g</b>. Details (sensitivity, uncertainty) in the log.",
"Aktueller Faktor {0} Counts/g":"Current factor {0} counts/g",
"Noch nicht kalibriert (Schätzwert)":"Not calibrated yet (estimate)",
"Ohne Tara im Dialog kalibrieren? Der aktuelle Nullpunkt wird verwendet.":"Calibrate without taring in this dialog? The current zero point will be used.",
"ALARM Treiber":"Driver ALARM",
"nicht eingerichtet":"not set up",
"Motorstrom aus":"motor current off",
"Last":"Load",
"{0} Schritte":"{0} steps",
"ab Werkzeug-Endpunkt":"from tool end point",
"relativ, noch nicht kalibriert":"relative, not calibrated yet",
"letzter Stopp:":"last stop:",
"Zuerst Schritte pro mm einstellen: mp spmm <Wert>":"Set steps per mm first: mp spmm <value>",
"Kontakt {0} mm unter dem Start":"Contact {0} mm below start",
"Endpunkt <b>+{0} Schritte</b> bei <b>{1} kg</b>":"End point <b>+{0} steps</b> at <b>{1} kg</b>",
"Maximalkraft erreicht":"max. force reached",
"Überlauf erreicht":"overtravel reached",
"noch keine":"none yet",
"Suche {0} mm/s · Kontakt ab {1} g Laständerung · Überlauf {2} Schritte · max. {3} kg · Hub {4} mm":"Search {0} mm/s · contact at {1} g load change · overtravel {2} steps · max. {3} kg · stroke {4} mm",
"keine Verbindung zum Pico":"no connection to the Pico",
"misst":"measuring",
"ADC angehalten":"ADC stopped",
"ADC nicht initialisiert":"ADC not initialised",
"verloren":"lost",
"Auftrag läuft":"job running",
"Faktor unkalibriert":"factor uncalibrated",
"geglättet über {0} s":"smoothed over {0} s",
"ungeglättet":"unsmoothed",
"Statistik über {0} Werte ({1} s, ungefiltert)":"Statistics over {0} values ({1} s, unfiltered)",
"Mittelwert":"Mean",
"Std.-Abw. σ":"Std. dev. σ",
"Spitze-Spitze":"Peak-to-peak",
"σ geglättet":"σ smoothed",
"<b>Effektive Auflösung:</b> {0} Bit · <b>rauschfrei:</b> {1} Bit":"<b>Effective resolution:</b> {0} bit · <b>noise-free:</b> {1} bit",
"<b>Bezogen auf Nennlast:</b> {0} Teile = {1} Bit":"<b>Relative to rated load:</b> {0} divisions = {1} bit",
"<b>Nach Mittelung auf 10 SPS:</b> {0} Teile = {1} Bit":"<b>After averaging to 10 SPS:</b> {0} divisions = {1} bit",
"Rate gemessen {0} SPS · verloren {1}":"Measured rate {0} SPS · lost {1}",
"ÜBERSTEUERT":"CLIPPED",
"g unkalibriert":"g uncalibrated",
"warte auf Messwerte …":"waiting for readings …",
"▲ Werte darüber":"▲ values above",
"▼ Werte darunter":"▼ values below",
"# Waegezelle Graphdaten (Mittel/Min/Max je Punkt), rate={0} SPS, Einheit={1}":"# Load cell chart data (mean/min/max per point), rate={0} SPS, unit={1}",
"t_ms,mittel,min,max,geglaettet":"t_ms,mean,min,max,smoothed",

"SIMULATION aktiv – die Kraft wird berechnet, nicht gemessen":"SIMULATION active – the force is calculated, not measured",
"Simulation beenden":"End simulation",
"Seiten":"Pages",
"Messseite":"Measurement page",
"Auswertung":"Analysis",
"Pressung & Liste":"Press & list",
"Trend & Auswertung":"Trend & analysis",
"Sitzungsstatistik":"Session statistics",
"Sitzungen":"Sessions",
"Parameter & Protokoll":"Parameters & log",
"Modus":"Mode",
"Menü ein-/ausklappen":"Collapse/expand menu",
"Ablauf":"Procedure",
"Kraft":"Force",
"Ohne Motor: die Kraft wird aus der Position berechnet":"Without motor: the force is calculated from the position",
"Simulation ohne Motor":"Simulation without motor",
"Geschwindigkeit, Weg, Kraft, Werkzeugabstand der Simulation":"Speed, path, force, tool distance of the simulation",
"Parameter …":"Parameters …",
"Werkzeug auflegen und tarieren":"Place the tool and tare",
"Mittelt etwa 2 s und setzt den Wert als Nullpunkt – Werkzeug liegt auf, kein Werkstück":"Averages for about 2 s and sets the value as zero point – tool in place, no workpiece",
"Sitzung wählen":"Select session",
"Sitzung wählen …":"Select session …",
"Werkstück einlegen und starten":"Insert the workpiece and start",
"Kraft über Weg":"Force over path",
"Klick: Pressung auswählen · Mausrad: zoomen (Umschalt: nur Weg) · Ziehen: verschieben · Doppelklick: alles":"Click: select press · mouse wheel: zoom (Shift: path only) · drag: pan · double-click: show all",
"Weg":"Path",
"ab Kontakt":"from contact",
"Krafteinheit":"Force unit",
"Anzeigen":"Show",
"alle":"all",
"letzte 10":"last 10",
"letzte 25":"last 25",
"letzte 50":"last 50",
"Abbrüche zeigen":"Show aborted",
"ab Kontakt zoomen":"Zoom from contact",
"Klick: ein-/ausklappen":"Click: collapse/expand",
"Pressungen ·":"Presses ·",
"Auswahl mit Plateau-Gerade (Fenster schattiert), ● Fügekraft, ▲ Einführspitze, ✕ größter Kraftabfall ·":"Selection with plateau line (window shaded), ● joining force, ▲ insertion peak, ✕ largest force drop ·",
"Rissverdacht / laufende Pressung ·":"Suspected crack / running press ·",
"Abbruch":"Aborted",
"Pressung":"Press",
"Noch keine Pressung ausgewählt.":"No press selected yet.",
"Pressungen":"Presses",
"Trend über die Pressungen":"Trend over the presses",
"Kennwert":"Indicator",
"Mittelwert (Linie) und ±3σ (gestrichelt) der gültigen Pressungen · Klick: Pressung auswählen":"Mean (line) and ±3σ (dashed) of the valid presses · click: select press",
"Plateau von [% der Fügetiefe]":"Plateau from [% of joining depth]",
"Plateau bis [% der Fügetiefe]":"Plateau to [% of joining depth]",
"Anschlag ausschließen [mm vor Endpunkt]":"Exclude end stop [mm before end point]",
"Wegfenster [mm ab Kontakt, mit ; getrennt]":"Path windows [mm from contact, separated by ;]",
"Rissverdacht ab Kraftabfall [%]":"Suspected crack from force drop [%]",
"… innerhalb von [mm]":"… within [mm]",
"Standardwerte":"Defaults",
"Auswertung als CSV":"Analysis as CSV",
"Fügetiefe = Kontakt bis Endpunkt minus Anschlag. Die Einstellungen gelten für alle Pressungen und werden in diesem Browser gespeichert.":"Joining depth = contact to end point minus end stop. The settings apply to all presses and are stored in this browser.",
"Verwaltung":"Management",
"Name der neuen Sitzung, z. B. Charge 2026-11-14 / Werkzeug A":"Name of the new session, e.g. Batch 2026-11-14 / Tool A",
"Notiz (optional)":"Note (optional)",
"Neue Sitzung anlegen":"Create new session",
"Aktive Sitzung schließen":"Close active session",
"Pressparameter":"Press parameters",
"Pressen ab [mm über Endpunkt, max. 10]":"Press from [mm above end point, max. 10]",
"Pressgeschw. [mm/s]":"Press speed [mm/s]",
"Haltezeit [ms]":"Hold time [ms]",
"Bei dieser Kraft hält der Motor sofort an (Pressung, Kalibrierung, Fahrt). Höchstens Nennlast.":"The motor stops immediately at this force (press, calibration, move). At most the rated load.",
"Maximalkraft [":"Max. force [",
"Laständerung, ab der beim Kalibrieren und Pressen ein Kontakt erkannt wird":"Load change at which contact is detected during calibration and pressing",
"Kontakt ab [":"Contact at [",
"Übernehmen":"Apply",
"Alle Einstellungen dauerhaft speichern (Befehl s)":"Save all settings permanently (command s)",
"Im Flash speichern":"Save to flash",
"Kraftmodell ohne Motor: virtuelles Werkzeug, je Pressung ein Werkstück mit zufälliger Spitzenkraft zwischen „von“ und „bis“. Die Werte gelten bis zum Neustart des Pico; dieser Browser merkt sie sich und schickt sie beim Einschalten der Simulation wieder.":"Force model without motor: virtual tool, one workpiece per press with a random peak force between “from” and “to”. The values apply until the Pico restarts; this browser remembers them and sends them again when the simulation is switched on.",
"Pressgeschwindigkeit [mm/s]":"Press speed [mm/s]",
"Werkzeugabstand (Hub bis zum Werkzeug) [mm]":"Tool distance (stroke to the tool) [mm]",
"Fügeweg (Werkstückhöhe) [mm]":"Joining path (workpiece height) [mm]",
"Spitzenkraft von [kg]":"Peak force from [kg]",
"Spitzenkraft bis [kg]":"Peak force to [kg]",
"Rauschen ± [g]":"Noise ± [g]",
"Rissquote [% der Pressungen]":"Crack rate [% of presses]",
"Einführspitze [% der Spitzenkraft]":"Insertion peak [% of peak force]",
"Ein geänderter Werkzeugabstand setzt das virtuelle Werkzeug neu: danach Hub kalibrieren. Anfahrpunkt und Haltezeit stehen unter „Pressparameter“.":"A changed tool distance resets the virtual tool: calibrate the stroke afterwards. Approach point and hold time are under “Press parameters”.",
"Jede Pressung wird sofort in der aktiven Sitzung gespeichert.":"Every press is saved immediately in the active session.",
"Name der neuen Sitzung":"Name of the new session",
"Neu anlegen":"Create",
"… oder eine vorhandene öffnen:":"… or open an existing one:",
"Alle Sitzungen verwalten":"Manage all sessions",
"Sitzung umbenennen":"Rename session",
"Notiz":"Note",
"Abbrechen":"Cancel",
"Sitzung: Aktion nicht ausgeführt – Grund im Protokoll":"Session: action not carried out – reason in the log",
"Sitzung: keine Verbindung zum Pico":"Session: no connection to the Pico",
"# Browser: Rohdaten konnten nicht gespeichert werden (IndexedDB)":"# Browser: raw data could not be saved (IndexedDB)",
"# Browser: keine Rohdaten für Pressung {0} gefunden":"# Browser: no raw data found for press {0}",
"Halten":"Hold",
"Drücken":"Press",
"Sitzung":"Session",
"Datenrate [SPS]":"Data rate [SPS]",
"Schritte/mm":"Steps/mm",
"Zeit [s]":"Time [s]",
"Weg [mm]":"Path [mm]",
"Kraft [{0}]":"Force [{0}]",
"Phase":"Phase",
"sitzung":"session",
"pressung":"press",
"roh":"raw",
"auswertung":"analysis",
"Fügekraft (ohne Anschlag)":"Joining force (without end stop)",
"Einführspitze":"Insertion peak",
"Plateau-Steigung":"Plateau slope",
"Plateau-Achsenabschnitt":"Plateau intercept",
"Laufruhe (σ um die Gerade)":"Smoothness (σ around the line)",
"Größter Kraftabfall":"Largest force drop",
"Arbeit im Plateaufenster":"Work in plateau window",
"Kraft bei {0} mm":"Force at {0} mm",
"Endkraft (am Anschlag)":"Final force (at end stop)",
"Kontaktposition":"Contact position",
"Presstiefe":"Press depth",
"Pressarbeit gesamt":"Press work (total)",
"Presszeit":"Press time",
"keine Verbindung":"no connection",
"ADC misst nicht":"ADC not measuring",
"<span class=\"warn\">Waage nicht kalibriert</span> – <a href=\"/#kalibrieren\">jetzt kalibrieren</a> (Messseite)":"<span class=\"warn\">Scale not calibrated</span> – <a href=\"/#kalibrieren\">calibrate now</a> (measurement page)",
"Kraft jetzt: <b>{0}</b>":"Force now: <b>{0}</b>",
" – tariert":" – tared",
" – mit Werkzeug „Tara“ drücken":" – press “Tare” with the tool in place",
"Werkzeug-Kontakt {0} mm unter Start, Endpunkt +{1} mm bei {2}":"Tool contact {0} mm below start, end point +{1} mm at {2}",
"nach jedem Einschalten nötig – Werkzeug aufgelegt, Werkstück entnommen":"required after every power-up – tool in place, workpiece removed",
"{0} Pressungen":"{0} presses",
"keine Sitzung aktiv":"no active session",
"bereit – START drücken (Knopf oder Taster)":"ready – press START (button or push-button)",
"{0} gültige Pressungen (ohne Abbrüche)":"{0} valid presses (without aborted)",
"{0} mit Rissverdacht":"{0} with suspected crack",
"Mittel":"Mean",
"Spannweite":"Range",
"Nr":"No.",
"Zeit":"Time",
"Fügekraft":"Joining force",
"Spitze":"Peak",
"Steigung":"Slope",
"Laufruhe":"Smoothness",
"Abfall":"Drop",
"Fend":"F end",
"Kurve anzeigen":"Show curve",
"Rohdaten (jeder Messwert) in diesem Browser":"Raw data (every reading) in this browser",
"Pressung {0}":"Press {0}",
"Rissverdacht":"Suspected crack",
"zum Mittel":"vs. mean",
"bei {0} mm":"at {0} mm",
"{0} – {1} mm ab Kontakt":"{0} – {1} mm from contact",
"{0} bei {1} SPS":"{0} at {1} SPS",
"{0} verloren":"{0} lost",
"Rohdaten: {0} Punkte, 1 Schritt = {1} µm":"Raw data: {0} points, 1 step = {1} µm",
"Rohdaten CSV":"Raw data CSV",
"Pico: {0} Punkte à {1} µm":"Pico: {0} points of {1} µm",
"{0} mm/s, Haltezeit {1} ms":"{0} mm/s, hold time {1} ms",
"abgeschlossen":"completed",
"Höchstkraft":"Max. force",
"Weg ab Kontakt [mm]":"Path from contact [mm]",
"Weg [mm]  (0 = Werkzeug-Endpunkt, + = tiefer)":"Path [mm]  (0 = tool end point, + = deeper)",
"Weg {0} mm · Kraft {1}":"Path {0} mm · force {1}",
"noch keine ausgewerteten Pressungen":"no analysed presses yet",
"Pressung Nr.":"Press no.",
"gestrichelt: ±3σ, orange: außerhalb ±3σ oder Rissverdacht · Klick: Pressung auswählen":"dashed: ±3σ, orange: outside ±3σ or suspected crack · click: select press",
"ja":"yes",
"Auswertung Sitzung":"Analysis of session",
"Erstellt":"Created",
"Plateaufenster [% der Fügetiefe]":"Plateau window [% of joining depth]",
"Anschlag ausgeschlossen [mm]":"End stop excluded [mm]",
"innerhalb [mm]":"within [mm]",
"Weg Fügekraft [mm]":"Path of joining force [mm]",
"Weg Einführspitze [mm]":"Path of insertion peak [mm]",
"Weg Kraftabfall [mm]":"Path of force drop [mm]",
"Statistik (gültige Pressungen)":"Statistics (valid presses)",
"Speicher: {0} von {1} KB belegt":"Storage: {0} of {1} KB used",
"aktiv":"active",
"Öffnen":"Open",
"Umbenennen":"Rename",
"Löschen":"Delete",
"Sitzung {0} „{1}“ mit {2} Pressungen endgültig löschen?":"Permanently delete session {0} “{1}” with {2} presses?",
"Vorher exportieren!":"Export it first!",
"Charge {0}":"Batch {0}",
"noch keine Sitzungen":"no sessions yet",
"Pressweg {0} mm (Anfahrpunkt, max. {1} mm) → ca. {2} s und {3} Messwerte bei {4} SPS.":"Press path {0} mm (approach point, max. {1} mm) → approx. {2} s and {3} readings at {4} SPS.",
"Hinweis: Fügeweg größer als der Anfahrpunkt – das Werkstück wird auf {0} mm gekürzt.":"Note: joining path larger than the approach point – the workpiece is shortened to {0} mm.",
"Hinweis: Spitzenkraft über der Maximalkraft – die Pressung endet früh.":"Note: peak force above the max. force – the press ends early.",
"Geänderte Werte (markiert) erst mit „Übernehmen“ senden.":"Send changed values (marked) with “Apply” first.",
"Eilgang {0} mm/s. Übernommene Werte gelten bis zum Neustart; dauerhaft mit „Im Flash speichern“.":"Rapid traverse {0} mm/s. Applied values last until restart; permanently with “Save to flash”.",
"Endpunkt erreicht":"End point reached",
"Kontakt":"Contact",
"Maximalkraft":"Max. force",
"Alarm vom Treiber":"Alarm from driver",
"STOPP-Taster":"STOP push-button",
"Stopp-Befehl":"Stop command",
"keine Messwerte":"no readings",
"kein Kontakt":"no contact",
"Sensorfehler":"Sensor fault",
"Kraft im Eilgang":"Force during rapid traverse",
"Höchste Kraft ab Kontakt bis vor den Anschlag – die eigentliche Einpresskraft":"Highest force from contact up to the end stop – the actual press-in force",
"Erstes deutliches Kraftmaximum beim Einführen (in den ersten 40 % der Fügetiefe)":"First clear force maximum during insertion (in the first 40 % of the joining depth)",
"Steigung der Ausgleichsgeraden im Plateaufenster: wie stark die Kraft mit dem Weg zunimmt":"Slope of the fitted line in the plateau window: how much the force rises with the path",
"Kraft der Plateau-Geraden beim Kontakt (Weg 0)":"Force of the plateau line at contact (path 0)",
"Streuung der Kraft um die Plateau-Gerade – klein = gleichmäßiges Fügen, groß = Ruckeln oder Fressen":"Scatter of the force around the plateau line – small = even joining, large = stick-slip or seizing",
"Größter Kraftrückgang innerhalb der eingestellten Strecke – ab dem eingestellten Prozentwert Rissverdacht":"Largest force decrease within the set distance – suspected crack from the set percentage",
"Fläche unter der Kurve im Plateaufenster":"Area under the curve in the plateau window",
"Kraft am Ende des Pressens (am Anschlag)":"Force at the end of pressing (at the end stop)",
"Weg, bei dem das Werkstück berührt wurde (0 = Werkzeug-Endpunkt)":"Path at which the workpiece was touched (0 = tool end point)",
"Weg vom Kontakt bis zum Ende des Pressens":"Path from contact to the end of pressing",
"Fläche unter der ganzen Kurve ab Kontakt":"Area under the whole curve from contact",
"Dauer des Pressens ohne Eilgang und Rückfahrt":"Duration of pressing without rapid traverse and return",
"Kraft genau bei diesem Weg ab Kontakt":"Force exactly at this path from contact",
"abgeschlossen = ohne Abbruch beendet. Sagt nichts über die Qualität des Teils.":"completed = finished without abort. Says nothing about the quality of the part.",
"Fügen":"Joining",
"Wegfenster ab Kontakt":"Path windows from contact",
"Plateaufenster":"Plateau window",
"Höchstkraft gesamt (inkl. Anschlag)":"Max. force overall (incl. end stop)",
"Kraft nach Haltezeit":"Force after hold time",
"Zykluszeit":"Cycle time",
"Ende durch":"Ended by",
"Proben":"Samples",
"Kurve":"Curve",
"Einstellungen":"Settings",

"bereit":"ready",
"Fahrt":"Moving",
"Kontaktsuche":"Contact search",
"Ueberlauf":"Overtravel",
"Rueckfahrt":"Returning",
"Presse: Anfahrt":"Press: approach",
"Presse: Druecken":"Press: pressing",
"Presse: Halten":"Press: holding",
"Presse: Rueckfahrt":"Press: returning",
"Ziel erreicht":"Target reached",
"Kontakt erkannt":"Contact detected",
"kein Kontakt im Hub gefunden":"no contact found within the stroke",
"Sensorfehler (Messwert uebersteuert/eingefroren)":"Sensor fault (reading clipped/frozen)",
"ADC misst nicht ('init')":"ADC not measuring ('init')",
"Datenrate unter 500 SPS ('r 2000')":"Data rate below 500 SPS ('r 2000')",
"Waage nicht kalibriert ('k <g>')":"Scale not calibrated ('k <g>')",
"Antrieb nicht eingerichtet ('mp spmm')":"Drive not set up ('mp spmm')",
"Hub nicht kalibriert (nach jedem Einschalten noetig)":"Stroke not calibrated (required after every power-up)",
"Speicher voll - Sitzungen exportieren und loeschen":"Storage full – export and delete sessions",
"Auftrag laeuft (Tara, Kalibrierung, Rauschtest)":"Job running (tare, calibration, noise test)",
"Antrieb faehrt":"Drive moving",
"Treiber meldet Alarm":"Driver reports alarm",
"Antrieb steht nicht ueber dem Endpunkt ('mot auf <mm>')":"Drive is not above the end point ('mot auf <mm>')"
}/*ENDE*/;
// Firmware-Texte (ASCII) für die deutsche Anzeige
const DE_TEXT={"Ueberlauf":"Überlauf","Rueckfahrt":"Rückfahrt","Presse: Druecken":"Presse: Drücken",
"Presse: Rueckfahrt":"Presse: Rückfahrt","Sensorfehler (Messwert uebersteuert/eingefroren)":"Sensorfehler (Messwert übersteuert/eingefroren)",
"Hub nicht kalibriert (nach jedem Einschalten noetig)":"Hub nicht kalibriert (nach jedem Einschalten nötig)",
"Speicher voll - Sitzungen exportieren und loeschen":"Speicher voll – Sitzungen exportieren und löschen",
"Auftrag laeuft (Tara, Kalibrierung, Rauschtest)":"Auftrag läuft (Tara, Kalibrierung, Rauschtest)","Antrieb faehrt":"Antrieb fährt",
"Antrieb steht nicht ueber dem Endpunkt ('mot auf <mm>')":"Antrieb steht nicht über dem Endpunkt ('mot auf <mm>')"};

const spHat=(o,k)=>Object.prototype.hasOwnProperty.call(o,k);
let SPR=(()=>{try{const s=localStorage.getItem("wz_sprache");if(s==="de"||s==="en")return s;}catch(e){}
  return /^de\b/i.test(navigator.language||"")?"de":"en";})();
document.documentElement.lang=SPR;
const LOC=()=>SPR==="en"?"en-US":"de-DE";
// Text aus dem Seitenskript: T("Kraft bei {0} mm",wert)
function T(s,...a){
  const t=SPR==="en"&&spHat(WOERTER,s)?WOERTER[s]:s;
  return a.length?t.replace(/\{(\d)\}/g,(m,i)=>i<a.length?String(a[i]):m):t;
}
// Text der Firmware (Zustand, Stoppgrund, Grund für "nicht bereit")
function TF(s){
  if(s===null||s===undefined)return "";
  const w=SPR==="en"?WOERTER:DE_TEXT;
  return spHat(w,s)?w[s]:s;
}

// ---------- statische Texte der Seite ----------
const spText=new WeakMap(),spAttr=new WeakMap(),spRueckrufe=[];
let spTitel=null;
const spNorm=s=>s.replace(/\s+/g," ").trim();
const spUeber=o=>{const k=spNorm(o);return SPR==="en"&&spHat(WOERTER,k)?o.replace(/^(\s*)[\s\S]*?(\s*)$/,"$1"+WOERTER[k].replace(/\$/g,"$$$$")+"$2"):o;};
function spUebersetzen(){
  if(spTitel===null)spTitel=document.title;
  document.title=spUeber(spTitel);
  const tw=document.createTreeWalker(document.body,NodeFilter.SHOW_ELEMENT|NodeFilter.SHOW_TEXT,
    {acceptNode:n=>n.nodeType===1&&/^(SCRIPT|STYLE|PRE|CANVAS)$/.test(n.nodeName)?NodeFilter.FILTER_REJECT:NodeFilter.FILTER_ACCEPT});
  for(let n=tw.nextNode();n;n=tw.nextNode()){
    if(n.nodeType===3){
      const o=spText.has(n)?spText.get(n):n.nodeValue;
      if(!spHat(WOERTER,spNorm(o)))continue;
      if(!spText.has(n))spText.set(n,o);
      n.nodeValue=spUeber(o);
      continue;
    }
    let m=spAttr.get(n);
    for(const a of ["title","placeholder","aria-label"]){
      if(!n.hasAttribute(a))continue;
      const o=m&&spHat(m,a)?m[a]:n.getAttribute(a);
      if(!spHat(WOERTER,spNorm(o)))continue;
      if(!m){m={};spAttr.set(n,m);}
      if(!spHat(m,a))m[a]=o;
      n.setAttribute(a,spUeber(o));
    }
    if(n.dataset.hrefEn){                                   // Link mit englischer Fassung (Hilfe)
      if(!n.dataset.hrefDe)n.dataset.hrefDe=n.getAttribute("href");
      n.setAttribute("href",SPR==="en"?n.dataset.hrefEn:n.dataset.hrefDe);
    }
  }
  document.querySelectorAll(".sprachwahl button").forEach(b=>b.classList.toggle("aktiv",b.dataset.l===SPR));
}
function spracheSetzen(l){
  if(l!=="de"&&l!=="en")return;
  SPR=l;document.documentElement.lang=l;
  try{localStorage.setItem("wz_sprache",l);}catch(e){}
  spUebersetzen();
  for(const f of spRueckrufe)f();
}
// Aufruf im Seitenskript, sobald die Bedienelemente aufgebaut sind: übersetzt die Seite;
// cb baut beim Umschalten die Anzeigen neu auf (nicht beim Start)
function spracheStart(cb){
  if(cb)spRueckrufe.push(cb);
  document.querySelectorAll(".sprachwahl button").forEach(b=>b.onclick=()=>spracheSetzen(b.dataset.l));
  spUebersetzen();
}
)SPRACHE";
